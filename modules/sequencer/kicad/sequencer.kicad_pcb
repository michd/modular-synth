# Repository michd/modular-synth

File README.md:

# Modular Synthesizer

My fiancee and I plan to build a modular synthesizer, for fun. Here's a repository to hold all kinds of stuff to do with that. I imagine it'll hold the following

- Schematic designs
- PCB designs derived from those schematic design
- Some 3D modeling for related hardware
- Any microcontroller code

## KiCad design modules/sequencer/kicad/sequencer.kicad_pcb

Parts:
AFF1: CC04-41SURKWA
C1, C2: 22p; C_0603
C3, C4: 470u; CP_Radial_D8.0mm_P3.50mm
C5, C6, C7, C8, C9, C10, C11, C12, C14, C16, C24, C25: 10u; C_0805
C13, C15, C17, C19, C21, C23: 100n; C_0402
C18: 330n; C_0603
C20, C22: 1u; C_0805
D1, D2, D3: LED; LED_D3.0mm
P1, P3: CONN_01X03; Molex_KK-6410-03_03x2.54mm_Straight
P2, P4, P5: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
P6: CONN_01X02; Molex_KK-6410-02_02x2.54mm_Straight
Q1: MMBT3904; SOT-23
Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10: MMBT3906; SOT-23
R1: 22k; R_1206
R2: 100R; R_1206
R3, R10, R11, R12, R14, R15, R16, R18, R20, R21, R22, R24, R26, R27: 10k; R_0603
R4, R5, R8, R13, R19, R23, R25, R28: 1k, .1%; R_0805
R6: 20k; R_0603
R7, R9: 100k; R_1206
R17: 2k2; R_1206
R29: 330R; R_0603
R30: 220k; R_0805
R31, R32: 1k; R_1206
RV1: 1k; Potentiometer_Triwood_RM-065
RV2, RV4, RV5, RV7, RV8, RV11, RV13, RV14, RV15: 100k; Potentiometer_Bourns_PTV09A-1_Horizontal
RV3, RV6, RV9, RV12, RV16, RV17, RV18, RV19: 100k; Bourns-PTL30-X
RV10: 3k3; Potentiometer_Triwood_RM-065
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10: SW_PUSH_SMALL_H; SW_PUSH_6mm
SW11: LED-BUTTON; 5GTH9
SW12: SWITCH_INV_MSM; MHS123K
SW13, SW14, SW15, SW16, SW17, SW18, SW20, SW21: SW_PUSH_DPDT; 6-pin-momentary-push-button
SW19: Switch_SPDT_x2; Pin_Header_Straight_1x03_Pitch2.54mm
U1: MAX7221; SOIC-24
U2: MCP23S17; SOIC-28
U3: ATmega32U4-AU(edit); TQFP-44_10x10mm_Pitch0.8mm
U4: MCP4921-E/SN; SOIC-8-N
U5: 74LS138; SO-16-N
U6, U7: CD4051; SO-16-N
U8: TL074; SOIC-14_N
U9: TS12A4517; SOIC-8-N
U10: MCP3202; SOIC-8-N
U11: MC14551B; SO-16-N
W1: CV2; Measurement_Point_Round-SMD-Pad_Big
W2: PITCH_CV; Measurement_Point_Round-SMD-Pad_Big
W3: STEP_SELECT; Measurement_Point_Round-SMD-Pad_Big
X1: CRYSTAL_SMD2; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
/STEP_A0: U3.37 ((ADC6/TDO)PF6), U5.1 (A0), U6.11 (A), U7.11 (A)
/STEP_A1: U3.39 ((ADC4/TCK)PF4), U5.2 (A1), U6.10 (B), U7.10 (B)
/STEP_A2: U3.25 ((ICP2/ADC8)PD4), U5.3 (A2), U6.9 (C), U7.9 (C)
CHAIN_CV2: P2.2, U11.3 (X1)
CHAIN_GATE: P2.3, U11.10 (Y1)
CHAIN_IN: P2.5, U2.25 (GPA4)
CHAIN_OUT: P5.5, U2.26 (GPA5)
CHAIN_PITCH_CV: P2.1, U11.1 (W1)
CHAIN_TRIGGER: P2.4, U11.12 (Z1)
CV2: U7.3 (IN/OUT), U11.2 (X0), W1.1
CV2_OUT: P5.2, P6.2, R32.1
DECODER_ENABLE: U3.31 ((OC3A/~OC4A~)PC6), U5.6 (E3)
EXTERNAL_CLOCK: P3.1, U3.1 ((INT6/AIN0)PE6)
GATE: U3.30 ((ADC13/OC1B/OC4B/PCINT13)PB6), U11.6 (Y0)
GATE_OUT: P3.2, P5.3, U11.5 (Y)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.1, C7.2, C8.1, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.1, P1.2, P2.6, P4.6, P5.6, R4.2, R11.1, R29.1, R30.2, RV3.1, RV6.1, RV9.1, RV12.1, RV16.1, RV17.1, RV18.1, RV19.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2 (K), SW11.4 (SW2), SW12.2, U1.4 (GND), U1.9 (GND), U2.10 (VSS), U2.15 (A0), U2.16 (A1), U2.17 (A2), U3.15 (GND), U3.23 (GND), U3.35 (GND), U3.43 (GND), U4.5 (~LDAC~), U4.7 (AVSS), U5.4 (E1), U5.5 (E2), U5.8 (GND), U6.6 (INH), U6.7 (VEE), U6.8 (VSS), U7.6 (INH), U7.8 (VSS), U8.5 (+), U10.4 (Vss), U11.8 (VSS), X1.2 (GND), X1.4 (GND)
ISP_RESET: P4.5, U3.13 (RESET)
unnamed: AFF1.1 (d1,2), AFF1.6 (d3,4), U1.23 (SEG_D)
unnamed: AFF1.2 (DP1,2), AFF1.7 (DP3,4), U1.22 (SEG_DP)
unnamed: AFF1.3 (e1,2), AFF1.8 (e3,4), U1.21 (SEG_E)
unnamed: AFF1.4 (c1,2), AFF1.9 (c3,4), D3.2 (A), U1.20 (SEG_C)
unnamed: AFF1.5 (Dig2), U1.11 (DIG_1)
unnamed: AFF1.10 (dig4), U1.7 (DIG_3)
unnamed: AFF1.11 (b3,4), AFF1.16 (b1,2), D2.2 (A), U1.16 (SEG_B)
unnamed: AFF1.12 (a3,4), AFF1.17 (a1,2), D1.2 (A), U1.14 (SEG_A)
unnamed: AFF1.13 (f3,4), AFF1.18 (f1,2), U1.15 (SEG_F)
unnamed: AFF1.14 (g3,4), AFF1.19 (g1,2), U1.17 (SEG_G)
unnamed: AFF1.15 (Dig3), U1.6 (DIG_2)
unnamed: AFF1.20 (Dig1), U1.2 (DIG_0)
unnamed: C1.1, U3.17 (XTAL1), X1.1
unnamed: C2.1, U3.16 (XTAL2), X1.3
unnamed: C22.1, SW19.3 (C)
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), U1.3 (DIG_4)
unnamed: Q1.1 (B), R3.2
unnamed: Q1.2 (E), SW11.3 (A)
unnamed: Q1.3 (C), R2.1
unnamed: Q2.1 (B), R10.2
unnamed: Q2.2 (E), RV3.E
unnamed: Q3.1 (B), R12.1
unnamed: Q3.3 (C), R14.1, U9.6 (IN)
unnamed: Q4.1 (B), R15.2
unnamed: Q4.2 (E), RV6.E
unnamed: Q5.1 (B), R18.2
unnamed: Q5.2 (E), RV9.E
unnamed: Q6.1 (B), R21.2
unnamed: Q6.2 (E), RV12.E
unnamed: Q7.1 (B), R22.2
unnamed: Q7.2 (E), RV16.E
unnamed: Q8.1 (B), R24.2
unnamed: Q8.2 (E), RV17.E
unnamed: Q9.1 (B), R26.2
unnamed: Q9.2 (E), RV18.E
unnamed: Q10.1 (B), R27.2
unnamed: Q10.2 (E), RV19.E
unnamed: Q2.3 (C), Q4.3 (C), Q5.3 (C), Q6.3 (C), Q7.3 (C), Q8.3 (C), Q9.3 (C), Q10.3 (C), R29.2
unnamed: R1.2, U1.18 (ISET)
unnamed: R4.1, R5.2, SW13.1, SW13.6
unnamed: R5.1, R8.2, SW14.1, SW14.6
unnamed: R6.2, RV1.1
unnamed: R7.1, R9.2, U8.2 (-)
unnamed: R7.2, U4.8 (VoutA)
unnamed: R10.1, U5.15 (O0)
unnamed: R11.2, RV1.3
unnamed: R13.1, R19.2, SW16.1, SW16.6
unnamed: R8.1, R13.2, SW15.1, SW15.6
unnamed: R15.1, U5.14 (O1)
unnamed: R16.1, R17.2, U8.6 (-)
unnamed: R9.1, R16.2, U8.1
unnamed: R17.1, RV10.1
unnamed: R18.1, U5.13 (O2)
unnamed: R19.1, R23.2, SW17.1, SW17.6
unnamed: R20.1, RV13.3, U8.7, U9.1 (COM)
unnamed: R20.2, RV10.2, RV10.3
unnamed: R21.1, U5.12 (O3)
unnamed: R22.1, U5.11 (O4)
unnamed: R23.1, R25.2, SW18.1, SW18.6
unnamed: R24.1, U5.10 (O5)
unnamed: R25.1, R28.2, SW20.1, SW20.6
unnamed: R26.1, U5.9 (O6)
unnamed: R27.1, U5.7 (O7)
unnamed: R30.1, SW13.2, SW13.5, SW14.2, SW14.5, SW15.2, SW15.5, SW16.2, SW16.5, SW17.2, SW17.5, SW18.2, SW18.5, SW20.2, SW20.5, SW21.2, SW21.5, U10.3 (CH1), W3.1
unnamed: R31.2, U8.8, U8.9 (-)
unnamed: R32.2, U8.13 (-), U8.14
unnamed: RV1.2, U8.3 (+)
unnamed: RV2.2, U7.13 (X0)
unnamed: RV3.2, U6.13 (X0)
unnamed: RV4.2, U7.14 (X1)
unnamed: RV5.2, U7.15 (X2)
unnamed: RV6.2, U6.14 (X1)
unnamed: RV7.2, U7.12 (X3)
unnamed: RV8.2, U7.1 (X4)
unnamed: RV9.2, U6.15 (X2)
unnamed: RV11.2, U7.5 (X5)
unnamed: RV12.2, U6.12 (X3)
unnamed: RV14.2, U7.2 (X6)
unnamed: RV15.2, U7.4 (X7)
unnamed: RV16.2, U6.1 (X4)
unnamed: RV17.2, U6.5 (X5)
unnamed: RV18.2, U6.2 (X6)
unnamed: RV19.2, U6.4 (X7)
unnamed: SW1.1, U2.21 (GPA0)
unnamed: SW2.1, U2.22 (GPA1)
unnamed: SW3.1, U2.27 (GPA6)
unnamed: SW4.1, U2.1 (GPB0)
unnamed: SW5.1, U2.2 (GPB1)
unnamed: SW6.1, U2.3 (GPB2)
unnamed: SW7.1, U2.5 (GPB4)
unnamed: SW8.1, U2.6 (GPB5)
unnamed: SW9.1, U2.7 (GPB6)
unnamed: SW10.1, U2.8 (GPB7)
unnamed: SW11.1 (SW1), U2.4 (GPB3)
unnamed: SW12.1, U2.24 (GPA3)
unnamed: SW12.3, U2.23 (GPA2)
unnamed: U6.3 (IN/OUT), U10.2 (CH0)
unnamed: U8.12 (+), U11.4 (X)
unnamed: U8.10 (+), U11.14 (W)
PITCH_CV: C18.1, RV13.1, RV13.2, SW19.2 (B), U9.8 (NC), U11.15 (W0), W2.1
PITCH_CV_OUT: P5.1, P6.1, R31.1
PORTEXP_INT: U2.20 (INTA), U3.18 ((OC0B/SCL/INT0)PD0)
ROUTE_CHAINED: U3.21 ((TXD/INT3)PD3), U11.9 (CONTROL)
RUN_INDICATOR: R3.1, U3.28 ((ADC11/PCINT4)PB4)
SLIDE_OFF: R12.2, U3.20 ((RXD/INT2)PD2)
SPI_CS_ADC: U3.27 ((T0/OC4D/ADC10)PD7), U10.1 (CS)
SPI_CS_DAC: U3.38 ((ADC5/TMS)PF5), U4.2 (~CS~)
SPI_CS_DISPLAY: U1.12 (CS), U3.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5)
SPI_CS_PE: U2.11 (CS), U3.36 ((ADC7/TDI)PF7)
SPI_MISO: P4.1, U2.14 (SO), U3.11 ((PDO/MISO/PCINT3)PB3), U10.6 (DOUT)
SPI_MOSI: P4.4, U1.1 (DIN), U2.13 (SI), U3.10 ((PDI/MOSI/PCINT2)PB2), U4.4 (SDI), U10.5 (DIN)
SPI_SCK: P4.3, U1.13 (CLK), U2.12 (SCK), U3.9 ((SCLK/PCINT1)PB1), U4.3 (SCK), U10.7 (CLK)
TRIGGER: U3.19 ((SDA/INT1)PD1), U11.11 (Z0)
TRIGGER_OUT: P3.3, P5.4, U11.13 (Z)
VCC: C3.1, C5.1, C7.1, C9.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C19.1, C20.1, C21.1, C23.1, C24.1, P1.3, P4.2, Q3.2 (E), R1.1, R2.2, R6.1, R28.1, RV2.1, RV3.3, RV3.B, RV4.1, RV5.1, RV6.3, RV6.B, RV7.1, RV8.1, RV9.3, RV9.B, RV11.1, RV12.3, RV12.B, RV14.1, RV15.1, RV16.3, RV16.B, RV17.3, RV17.B, RV18.3, RV18.B, RV19.3, RV19.B, SW21.1, SW21.6, U1.19 (V+), U2.9 (VDD), U2.18 (RESET), U3.2 (UVCC), U3.14 (VCC), U3.24 (AVCC), U3.34 (VCC), U3.44 (AVCC), U4.1 (VDD), U4.6 (VrefA), U5.16 (VCC), U6.16 (VDD), U7.16 (VDD), U8.4 (V+), U9.4 (V+), U10.8 (Vdd), U11.16 (VDD)
VEE: C4.2, C6.2, C8.2, C10.2, C25.2, P1.1, R14.2, RV2.3, RV4.3, RV5.3, RV7.3, RV8.3, RV11.3, RV14.3, RV15.3, U7.7 (VEE), U8.11 (V-), U9.7 (V-), U11.7 (VEE)

Notes on the sheet:
TRIM
Output pitch CV scaling
DC offset
Amp
Slide potentiometer LED drivers
CV2 input potentiometers
Pitch CV Input potentiometers
Analog Multiplexers
Non-panel switch for longer slide times
Slide time Pot
Output pitch slide
Step select voltage
Pitch CV input voltage (0-5V), to be quantized, scaled
Param select A
Param select B
Chain input
Chain output
Up arrow
Down arrow
Slide
Gate mode
Step repeat
Sequence mode
Run / stop
Scale
Reset
Load
Save
IO10, A10
IO9, A9
IO8, A8
MISO, 14
MOSI, 16
SCK, 15
3, SCL
2, SDA
0, RX
1, TX
4, A6
6, A7

Board: 2 copper layers, 149.3 x 104.5 mm, 132 parts (89 on the bottom side), 133 nets.

## KiCad design modules/clock-generator/kicad/clock-generator.kicad_pcb

Parts:
C1: 100u; CP_Radial_D5.0mm_P2.00mm
C2: 10u; C_1206
C3, C4, C8: 100n; C_0805
C6, C7: 100p; C_0805
D1: LED; LED_D5.0mm
IC1: ATTINY84-S; SOIC-14_3.9x8.7mm_Pitch1.27mm
LD1: LB303AK
P1: CONN_01X03; Molex_KK-6410-03_03x2.54mm_Straight
P2: CONN_02X03; Pin_Header_Angled_2x03_Pitch2.54mm
P3: CONN_01X09; Molex_KK-6410-09_09x2.54mm_Straight
Q1: Q_NPN_BEC; SOT-23
R1: 22k; R_1206
R2: 10k; R_0603
R3: 220R; R_1206
SW1, SW2: SW_PUSH; SW_PUSH_6mm
U1: MAX7221; MAX7221-SOIC
U2: 4024; SOIC-14_3.9x8.7mm_Pitch1.27mm
Y1: 16MHz; Resonator-2pin_w10.0mm_h5.0mm

Connections:
DOUBLE_OUT: P3.8, U2.4 (Q5)
EIGHTH_OUT: P3.4, U2.11 (Q1)
GND: C1.2, C2.2, C3.2, C4.2, C6.1, C7.2, C8.2, D1.1 (K), IC1.14 (GND), P1.2, P2.6, SW1.1, SW2.1, U1.4 (GND), U1.9 (GND), U2.2 (MR), U2.7 (VSS)
HALF_OUT: P3.6, U2.6 (Q3)
LONG_OUT: P3.9, U2.3 (Q6)
unnamed: C6.2, IC1.2 ((PCINT8/CLKI/XTAL1)PB0), Y1.2
unnamed: C7.1, IC1.3 ((PCINT9/XTAL2)PB1), Y1.1
unnamed: D1.2 (A), Q1.2 (E)
unnamed: IC1.4 ((PCINT11/dW/~RESET~)PB3), P2.5
unnamed: IC1.7 ((PCINT6/SDA/DI/MOSI/OC1A/ADC6)PA6), P2.4, U1.1 (DIN)
unnamed: IC1.8 ((PCINT5/DO/MISO/OC1B/ADC5)PA5), P2.1
unnamed: IC1.9 ((PCINT4/USCK/SCL/T1/ADC4)PA4), P2.3, U1.13 (CLK)
unnamed: IC1.10 ((PCINT3/T0/ADC3)PA3), U1.12 (CS)
unnamed: IC1.11 ((PCINT2/AIN1/ADC2)PA2), SW1.2
unnamed: IC1.12 ((PCINT1/AIN0/ADC1)PA1), SW2.2
unnamed: LD1.1 (SEG_C), U1.20 (SEG_C)
unnamed: LD1.2 (DIG_1), U1.2 (DIG_0)
unnamed: LD1.3 (SEG_D), U1.23 (SEG_D)
unnamed: LD1.4 (DIG_2), U1.11 (DIG_1)
unnamed: LD1.5 (DIG_3), U1.6 (DIG_2)
unnamed: LD1.6 (SEG_DP), U1.22 (SEG_DP)
unnamed: LD1.7 (SEG_B), U1.16 (SEG_B)
unnamed: LD1.8 (SEG_F), U1.15 (SEG_F)
unnamed: LD1.9 (SEG_A), U1.14 (SEG_A)
unnamed: LD1.10 (SEG_E), U1.21 (SEG_E)
unnamed: LD1.11 (SEG_G), U1.17 (SEG_G)
unnamed: Q1.1 (B), R2.1
unnamed: Q1.3 (C), R3.2
unnamed: R1.2, U1.18 (ISET)
PPQ_OUT: IC1.6 ((PCINT7/ICP/OC0B/ADC7)PA7), P3.1
QUARTER_OUT: P3.5, R2.2, U2.9 (Q2)
SIXTEENTH_OUT: P3.3, U2.12 (Q0)
THIRTYSECOND_OUT: IC1.13 ((PCINT0/AREF/ADC0)PA0), P3.2, U2.1 (~CLK)
VCC: C1.1, C2.1, C3.1, C4.1, C8.1, IC1.1 (VCC), P1.3, P2.2, R1.1, R3.1, U1.19 (V+), U2.14 (VDD)
WHOLE_OUT: P3.7, U2.5 (Q4)

Notes on the sheet:
TEMPO UP
TEMPO DOWN
BPM indicator LED
Decoupling caps
ISP connector

Board: 2 copper layers, 50.5 x 47.0 mm, 22 parts (17 on the bottom side), 35 nets.

## KiCad design modules/distortion/kicad/distortion.kicad_pcb

Parts:
C1, C2: 470u; CP_Radial_D8.0mm_P3.50mm
C3, C4, C5, C6, C7, C8, C9: 10u; CP_Radial_D4.0mm_P1.50mm
C10: 1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1, D2: D; D_DO-35_SOD27_P7.62mm_Horizontal
P1, P2: CONN_01X03; Molex_KK-6410-03_03x2.54mm_Straight
P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14: CONN_01X03; Socket_Strip_Straight_1x03_Pitch2.54mm
R1, R4, R6, R7, R8, R9, R10, R12, R14, R19: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R20: 330k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 75k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R11, R13, R17, R18: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15, R16: 180k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R21: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2, RV3, RV4, RV5, RV6: 100k; Potentiometer_Bourns_PTV09A-1_Horizontal
U1: TL072; DIP-8_W7.62mm_LongPads
U2: TL974; DIP-14_W7.62mm_Socket_LongPads
U3: TL074; DIP-14_W7.62mm_Socket_LongPads
U4: 4066; DIP-14_W7.62mm_Socket_LongPads

Connections:
GND: C1.2, C2.1, C3.2, C4.1, C5.2, C6.1, C7.2, C8.1, C9.2, P2.2, P3.1, P7.3, P8.1, P14.3, R9.1, R10.2, U1.3 (+), U1.5 (+), U2.3 (+), U2.12 (+), U3.5 (+), U4.6 (ON), U4.7 (V-), U4.8 (I/O), U4.9 (O/I), U4.10 (O/I), U4.11 (I/O), U4.12 (ON)
GNDA: P4.1, P5.3, P6.1, P12.3, RV1.3, RV2.3, RV3.1, RV6.1
unnamed: C10.1, R20.1, U3.7
unnamed: C10.2, R21.2
unnamed: D1.1 (K), R9.2, U4.13 (ON)
unnamed: D1.2 (A), U2.7
unnamed: D2.1 (K), R10.1, U4.5 (ON)
unnamed: D2.2 (A), U2.8
unnamed: P3.2, R2.2, U1.2 (-)
unnamed: P4.2, R1.1
unnamed: P4.3, RV1.1
unnamed: P5.1, RV3.3
unnamed: P5.2, R4.1
unnamed: P6.2, R3.1
unnamed: P6.3, RV2.1
unnamed: P7.2, P8.2, R5.2, U2.2 (-)
unnamed: P9.1, R11.1
unnamed: P9.2, RV4.2
unnamed: P9.3, R13.1
unnamed: P10.1, R15.2, U3.13 (-)
unnamed: P10.2, P11.1, R2.1, R6.2, U1.1
unnamed: P10.3, R16.2, U3.9 (-)
unnamed: P11.2, U3.3 (+)
unnamed: P11.3, U4.2 (O/I), U4.3 (O/I)
unnamed: P12.1, RV6.3
unnamed: P12.2, R19.1
unnamed: P13.1, R18.1
unnamed: P13.2, RV5.2
unnamed: P13.3, R17.1
unnamed: P14.1, U3.1, U3.2 (-)
unnamed: P14.2, R20.2, U3.6 (-)
unnamed: R1.2, RV1.2
unnamed: R3.2, RV2.2
unnamed: R4.2, RV3.2
unnamed: R6.1, U2.5 (+), U2.9 (-)
unnamed: R7.1, R8.2, U2.13 (-)
unnamed: R11.2, RV4.3
unnamed: R12.1, U3.12 (+)
unnamed: R8.1, R12.2, U2.6 (-), U2.14
unnamed: R13.2, RV4.1
unnamed: R14.1, U3.10 (+)
unnamed: R5.1, R7.2, R14.2, U2.1, U2.10 (+)
unnamed: R15.1, U3.14, U4.1 (I/O)
unnamed: R16.1, U3.8, U4.4 (I/O)
unnamed: R17.2, RV5.1
unnamed: R18.2, RV5.3
unnamed: R19.2, RV6.2
unnamed: U1.6 (-), U1.7
SignalIn: P1.3, P3.3
SignalOut: P1.1, R21.1
ThresholdIn: P1.2, P7.1
VCC: C1.1, C3.1, C5.1, C7.1, C9.1, P2.3, P8.3, U1.8 (V+), U2.4 (V+), U3.4 (V+), U4.14 (V+)
VEE: C2.2, C4.2, C6.2, C8.2, P2.1, U1.4 (V-), U2.11 (V-), U3.11 (V-)

Notes on the sheet:
THRESHOLD
SYMMETRY
DEPTH
POST GAIN
PRE GAIN
THRESHOLD DEPTH
