# Repository michd/modular-synth (continued)

## KiCad design modules/distortion/kicad/distortion.kicad_pcb (continued)

Board: 2 copper layers, 50.0 x 132.2 mm, 60 parts (45 on the bottom side), 53 nets.

Other parts of the board:
mouse-bite-2mm-slot, mouse-bite-2mm-slot#2, mouse-bite-2mm-slot#3: VAL**; mouse-bite-2mm-slot

## KiCad design modules/inverter/kicad/inverter.kicad_pcb

Parts:
C1, C2: 470u
C3, C4: 10u
P1, P2, P3, P4, P5, P6: CONN_01X02
P7: CONN_01X03
Q1, Q2: Q_NPN_EBC
R1, R2, R3, R4, R5, R6, R7, R8: 100K
R9, R10, R11, R12: 1K
R13, R14, R15, R16: 10K
U1: TL074

Connections:
GND: C1.2, C2.1, C3.2, C4.1, P7.2, Q1.1 (E), Q2.1 (E), U1.3 (+), U1.5 (+), U1.10 (+), U1.12 (+)
unnamed: P1.1, R1.2
unnamed: P1.2, R9.1
unnamed: P2.1, R2.2
unnamed: P2.2, R10.1
unnamed: P3.1, R3.2
unnamed: P3.2, R11.1
unnamed: P4.1, R4.2
unnamed: P4.2, R12.1
unnamed: P5.1, R13.2
unnamed: P5.2, Q1.3 (C), R15.1
unnamed: P6.1, R14.2
unnamed: P6.2, Q2.3 (C), R16.1
unnamed: Q1.2 (B), R13.1
unnamed: Q2.2 (B), R14.1
unnamed: R1.1, R5.2, U1.2 (-)
unnamed: R2.1, R6.2, U1.6 (-)
unnamed: R3.1, R7.2, U1.9 (-)
unnamed: R4.1, R8.2, U1.13 (-)
unnamed: R5.1, R9.2, U1.1
unnamed: R6.1, R10.2, U1.7
unnamed: R7.1, R11.2, U1.8
unnamed: R8.1, R12.2, U1.14
VCC: C1.1, C3.1, P7.3, R15.2, R16.2, U1.11 (V-)
VEE: C2.2, C4.2, P7.1, U1.4 (V+)

Notes on the sheet:
Digital inverters
Analog inverters

Board: 2 copper layers, 49.3 x 51.8 mm, 30 parts (0 on the bottom side), 25 nets.

## KiCad design modules/reverb/kicad/reverb.kicad_pcb

Parts:
C1, C11, C15, C16: 1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
C2, C3: 470u; CP_Radial_D8.0mm_P3.50mm
C4, C5, C6, C7, C8, C9, C12: 10u; CP_Radial_D4.0mm_P1.50mm
C10: 22n; C_Disc_D4.7mm_W2.5mm_P5.00mm
C13: 47n; C_Disc_D4.7mm_W2.5mm_P5.00mm
C14: 220u; CP_Radial_D10.0mm_P3.80mm
C17: 100n; C_Disc_D4.7mm_W2.5mm_P5.00mm
C18: 100p; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1, D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
P1, P3, P6, P7, P8, P9: CONN_01X02; Molex_KK-6410-02_02x2.54mm_Straight
P2, P4, P5: CONN_01X03; Molex_KK-6410-03_03x2.54mm_Straight
Q1, Q2: 2N3906; TO-92_Inline_Narrow_Oval
R1, R2: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4, R5, R6, R7, R10, R15, R28, R29: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R9: 39k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11, R12, R30: 6k8; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14, R18, R19, R33, R34: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16, R17, R21, R22: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R20: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R23, R24: 56k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R25, R26: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R27: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R31: 470k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R32: 150k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1, U2: TL074; DIP-14_W7.62mm_LongPads
U3: LM386; DIP-8_W7.62mm_LongPads
U4: LM13700; DIP-16_W7.62mm_LongPads

Connections:
DRY-SIGNAL: R10.1, R13.2, R17.2, U2.14
GND: C2.2, C3.1, C4.2, C5.1, C6.2, C7.1, C8.2, C9.1, C11.1, C12.2, C17.2, P1.2, P3.1, P5.2, P6.1, P7.2, P8.1, R11.2, R12.2, R14.1, R15.2, R18.2, R19.2, R20.2, R23.1, R24.1, R27.2, U1.3 (+), U1.12 (+), U2.5 (+), U2.10 (+), U2.12 (+), U3.2 (-), U3.4 (Gnd), U4.4 (INPUT(-)), U4.13 (INPUT(-))
unnamed: C1.1, R7.2
unnamed: C1.2, P6.2
unnamed: C10.1, R15.1, U3.3 (+)
unnamed: C10.2, R13.1, R14.2
unnamed: C12.1, U3.7
unnamed: C13.1, C14.1, U3.5
unnamed: C13.2, R20.1
unnamed: C14.2, P7.1
unnamed: C15.1, R28.1
unnamed: C15.2, R25.2, U4.9 (BUFFER_OUTPUT)
unnamed: C16.1, R29.1
unnamed: C16.2, R26.2, U4.8 (BUFFER_OUTPUT)
unnamed: C17.1, R30.2
unnamed: C18.2, R30.1, R31.2, U2.2 (-)
unnamed: D1.1 (K), Q1.1 (E), R11.1, U1.9 (-)
unnamed: D1.2 (A), Q1.2 (B), U1.8
unnamed: D2.1 (K), Q2.1 (E), R12.1, U1.6 (-)
unnamed: D2.2 (A), Q2.2 (B), U1.7
unnamed: P1.1, R3.2
unnamed: P2.1, R1.1
unnamed: P2.2, R4.2
unnamed: P3.2, R5.2
unnamed: P4.2, R6.2
unnamed: P4.3, R2.1
unnamed: P8.2, R27.1, U2.3 (+)
unnamed: P9.1, R33.2
unnamed: P9.2, R34.2
unnamed: Q1.3 (C), U4.16 (AMP_BIAS_INPUT)
unnamed: Q2.3 (C), U4.1 (AMP_BIAS_INPUT)
unnamed: R3.1, R4.1, R8.2, U1.13 (-)
unnamed: R5.1, R6.1, R9.2, U1.2 (-)
unnamed: R8.1, U1.10 (+), U1.14
unnamed: R9.1, U1.1, U1.5 (+)
unnamed: R7.1, R10.2, U2.13 (-)
unnamed: R16.1, R18.1, U4.14 (INPUT(+))
unnamed: R17.1, R19.1, U4.3 (INPUT(+))
unnamed: R21.1, R23.2, U4.10 (BUFFER_INPUT), U4.12 (OUTPUT)
unnamed: R22.1, R24.2, U4.5 (OUTPUT), U4.7 (BUFFER_INPUT)
unnamed: R28.2, R29.2, R32.1, U2.6 (-)
unnamed: R32.2, R34.1, U2.7
unnamed: U2.8, U2.9 (-)
VCC: C2.1, C4.1, C6.1, C8.1, C11.2, P2.3, P4.1, P5.3, R21.2, R22.2, U1.4 (V+), U2.4 (V+), U3.6 (V+), U4.11 (V+)
VEE: C3.2, C5.2, C7.2, C9.2, P5.1, R1.2, R2.2, R25.1, R26.1, U1.11 (V-), U2.11 (V-), U4.6 (V-)
WET-SIGNAL: C18.1, R16.2, R31.1, R33.1, U2.1

Notes on the sheet:
Audio in
Spring tank
Wet Level CV
Wet Level Pot
Dry Level CV
Dry Level Pot
Wet Out Mix Out

Board: 2 copper layers, 58.9 x 89.1 mm, 69 parts (0 on the bottom side), 46 nets.

## KiCad design modules/adsr-envelope-generator/kicad/adsr-envelope-generator.kicad_pcb

Parts:
C1, C2, C3, C14, C19, C20, C22: 100n; C_0805
C4, C5: 100p; C_0805
C6: 3.3u; CP_Radial_D4.0mm_P1.50mm
C7, C8, C21: 10n; C_0805
C9: 100u; CP_Radial_D5.0mm_P2.00mm
C10: 47u; CP_Radial_D5.0mm_P2.00mm
C11: 1n; C_0805
C12, C13: 470u; CP_Radial_D8.0mm_P3.50mm
C15, C16, C17, C18: 10u; SMD-1206_Pol
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: 1N4148; SOD-323
P1, P2, P6: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
P3, P4, P5: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
Q1, Q2, Q3, Q4, Q5: MMBT3904; SOT-23
R1, R14: 100R; R_0805
R2, R3, R9, R10, R15, R16, R18, R21, R25, R27, R28, R29, R30: 10K; R_0805
R4, R22: 33K; R_0805
R5, R8: 1K; R_0805
R6, R7, R11: 22K; R_0805
R12, R13, R20, R24: 1M; R_0805
R17, R19, R23, R26: 100K; R_0805
R31, R32, R33, R34: 220R; R_0805
RV1, RV2, RV3, RV4: 100K; Bourns-PTL30-X
RV5: 10K; Potentiometer_Triwood_RM-065
U1: 4066; SOIC-14_N
U2, U5: TL974; SOIC-14_N
U3: 40106; SOIC-14_N
U4: 4001; SOIC-14_N

Connections:
A-LED: R31.1, RV1.B
AdsrLevel: P5.1, R20.1, U2.10 (+), U5.1, U5.2 (-), U5.5 (+)
AttackState: R27.1, U1.13 (ON), U4.2, U4.4, U4.8, U4.12
D-LED: R32.1, RV3.B
DecayState: D9.1 (K), D11.1 (K), U1.12 (ON), U4.11
GND: C1.2, C2.2, C3.2, C6.2, C10.2, C12.2, C13.1, C14.2, C15.2, C16.1, C17.2, C18.1, C19.2, C20.2, C22.2, P3.3, P4.2, P5.3, R2.1, R3.1, R11.2, R15.2, R16.1, R17.2, R18.2, R19.2, R22.2, R25.2, R26.2, RV1.E, RV2.E, RV3.E, RV4.1, RV4.E, U1.4 (I/O), U1.6 (ON), U1.7 (V-), U1.8 (I/O), U1.9 (O/I), U3.7 (VSS), U3.11 (In), U4.7 (VSS)
unnamed: C1.1, R4.2, R11.1, U2.2 (-), U2.13 (-)
unnamed: C2.1, R5.1, R9.1, U3.1 (In)
unnamed: C3.1, R8.1, R10.1, U3.3 (In)
unnamed: C4.1, R6.2, R12.1, U2.3 (+)
unnamed: C4.2, D1.2 (A), R12.2, U2.1
unnamed: C5.1, R7.2, R13.1, U2.12 (+)
unnamed: C5.2, D2.2 (A), R13.2, U2.14
unnamed: C6.1, C9.1, R14.2, U5.3 (+)
unnamed: C7.1, D1.1 (K), D3.1 (K), R15.1
unnamed: C7.2, C8.2, R17.1, U4.1
unnamed: C8.1, D2.1 (K), D4.1 (K), R16.2, U3.5 (In)
unnamed: C9.2, P3.2
unnamed: C10.1, P3.1
unnamed: C11.1, D5.1 (K), R18.1
unnamed: C11.2, D6.1 (K), R19.1, U4.6
unnamed: C14.1, R21.2, R22.1, U5.10 (+)
unnamed: D3.2 (A), U3.2 (Out)
unnamed: D4.2 (A), U3.4 (Out)
unnamed: D5.2 (A), U3.6 (Out), U3.9 (In), U4.13
unnamed: D6.2 (A), R20.2, U2.8
unnamed: D7.1 (K), U3.13 (In)
unnamed: D8.1 (K), U3.12 (Out)
unnamed: D8.2 (A), D9.2 (A), Q3.1 (B), R29.2
unnamed: D7.2 (A), D10.1 (K), R24.1, U5.14
unnamed: D10.2 (A), D11.2 (A), Q1.1 (B), Q4.1 (B), R30.2
unnamed: D12.2 (A), P2.1
unnamed: P1.1, R8.2
unnamed: P1.2, R3.2, R7.1
unnamed: P2.2, R5.2
unnamed: Q2.1 (B), R27.2
unnamed: Q2.2 (E), R31.2
unnamed: Q3.2 (E), R32.2
unnamed: Q4.2 (E), R33.2
unnamed: Q5.1 (B), R28.2
unnamed: Q5.2 (E), R34.2
unnamed: R1.2, U1.1 (I/O)
unnamed: R14.1, RV1.2, RV2.2, RV3.2
unnamed: R23.2, RV5.1
unnamed: R24.2, RV5.2, U5.12 (+)
unnamed: RV1.1, U1.2 (O/I)
unnamed: RV2.1, U1.3 (O/I)
unnamed: RV3.1, U1.11 (I/O)
unnamed: RV4.2, U2.5 (+)
unnamed: RV4.3, U2.9 (-), U5.8, U5.9 (-)
unnamed: U3.8 (Out), U4.9
unnamed: U4.3, U4.5
unnamed: U5.6 (-), U5.7, U5.13 (-)
R-LED: R34.1, RV2.B
ReleaseState: R28.1, U1.5 (ON), U4.10
RetrigSW: C21.1, P6.1, Q1.2 (E), R25.1
S-LED: R33.1, RV4.B
SustainLevel: RV5.3, U1.10 (O/I), U2.6 (-), U2.7
TrigOut: C21.2, P5.2, R26.1
TriggerInput: D12.1 (K), P6.2, R2.2, R6.1
VCC: C12.1, C15.1, C17.1, C19.1, C20.1, C22.1, P4.3, Q1.3 (C), Q2.3 (C), Q3.3 (C), Q4.3 (C), Q5.3 (C), R1.1, R4.1, R9.2, R10.2, R21.1, R23.1, R29.1, R30.1, U1.14 (V+), U2.4 (V+), U3.14 (VDD), U4.14 (VDD), U5.4 (V+)
VEE: C13.2, C16.2, C18.2, P4.1, U2.11 (V-), U5.11 (V-)

Notes on the sheet:
"SET" on flipflop Spike caused by upward flank on gate/trigger
"RESET" on flipflop Spike caused by attack cycle comparator; ends attack cycle
MAX ADSR Level buffer
Sustain Lvl buffer
MAX level reached comparator
ADSR out buffer
To SPCO SW
Decoupling capacitors
Man Trig Btn
Trigger input
Gate input
Man Gate Btn

Board: 2 copper layers, 75.2 x 47.2 mm, 89 parts (85 on the bottom side), 62 nets.

## Code that names these connections

File modules/sequencer/code/main-arduino/io.h:

#ifndef MODULE_IO_H
#define MODULE_IO_H

// Chip select pins for the various SPI devices being used
#define PIN_SPI_CS_ADC 6
#define PIN_SPI_CS_DAC A2
#define PIN_SPI_CS_PORTEXP A0
#define PIN_SPI_CS_DISP 9

#define PIN_EXTERNAL_CLOCK 7

#define PIN_RUNNING_INDICATOR 8
#define PIN_GATE_OUT 10
#define PIN_TRIGGER_OUT 2
#define PIN_ROUTE_CHAINED_OUTPUT 1
#define PIN_ENABLE_SLIDE_OUTPUT 0

#define PIN_STEP_ADDR_A A1
#define PIN_STEP_ADDR_B A3
#define PIN_STEP_ADDR_C 4
#define PIN_STEP_ENABLE 5

#define PIN_PORTEXP_INTERRUPT 3

#define PORTEXP_PIN_GATE_MODE_SELECT_BUTTON 9
#define PORTEXP_PIN_REPEAT_SELECT_BUTTON 10
#define PORTEXP_PIN_SEQUENCE_MODE_SELECT_BUTTON 11
#define PORTEXP_PIN_RUN_MODE_BUTTON 12
#define PORTEXP_PIN_SCALE_BUTTON 13
#define PORTEXP_PIN_RESET_BUTTON 14
#define PORTEXP_PIN_LOAD_BUTTON 15
#define PORTEXP_PIN_SAVE_BUTTON 16
#define PORTEXP_PIN_UP_ARROW 1
#define PORTEXP_PIN_DOWN_ARROW 2
#define PORTEXP_PIN_PARAM_SELECT_A 3
#define PORTEXP_PIN_PARAM_SELECT_B 4
#define PORTEXP_PIN_CHAIN_INPUT 5
#define PORTEXP_PIN_CHAIN_OUTPUT 6
#define PORTEXP_PIN_SLIDE_BUTTON 7

#define PORTEXP_NUM_PINS 16

#define PORT_EXPANDER_CHANNEL 0

#define DEBOUNCE_TIME_MS 100

#define PARAM_MIN_NOTE 0b01
#define PARAM_MAX_NOTE 0b11
#define PARAM_TIME_DIVIDER 0b10

// Least significant byte describes bits to be written to a row
// Most significat bits describe which row to use
// Split up accordingly
#define LED_INDICATOR_NONE      0x400 // None of those LEDs on
#define LED_INDICATOR_STEP_NOTE 0x440
#define LED_INDICATOR_MAX_NOTE  0x420
#define LED_INDICATOR_MIN_NOTE  0x410

#define ADC_CV_CHANNEL 0
#define ADC_STEP_CHANNEL 1

#define ADC_RESOLUTION_BIT 12
#define DAC_RESOLUTION_BIT 12

#define DAC_CENTER_VALUE 2048
#define ADC_MAX 4096
#define DAC_MAX 4096

#define NUM_STEPS 8

// There are only 7 possible tasks, and none may be duplicated in the queue
#define MAX_TASK_QUEUE_LENGTH 7
#define DISPLAY_STRING_LENGTH 5 // 1 for the null terminator

#include <Arduino.h>
#include <String.h>
#include <stdint.h>

#include "MAX72S21.h" // Display driver
#include "MCP23S17.h" // Port expander
#include "MCP3202.h"  // ADC
#include "MCP492X.h"  // DAC

/*
 * MCP23S17 pin number mapping:
 * A0 -  1 | B0 -  9
 * A1 -  2 | B1 - 10
 * A2 -  3 | B2 - 11
 * A3 -  4 | B3 - 12
 * A4 -  5 | B4 - 13
 * A5 -  6 | B5 - 14
 * A6 -  7 | B6 - 15
 * A7 -  8 | B7 - 16
 *
 * When writing a word: order is MSB B7-B0 A7-A0 LSB
 */

/* SPI pins on pro micro for reference:
 * MOSI: 16
 * MISO: 14
 * SCK:  15
 */

enum Tasks {
    BLANK,
    READ_ADC,
    READ_SELECTED_STEP,
    WRITE_DAC,
    READ_PORTEXP,
    PROCESS_PORTEXP_INTERRUPT,
    WRITE_DISPLAY,
    WRITE_LEDS
  };

enum LEDs {
    INDICATOR_NONE,
    INDICATOR_STEP_NOTE,
    INDICATOR_MIN_NOTE,
    INDICATOR_MAX_NOTE
  };

typedef void (*AdcReadHandler)(unsigned int);
typedef void (*ButtonPressedHandler)(void);
typedef void (*ArrowButtonPressedHandler)(bool);
typedef void (*TickHandler)(void);
typedef void (*PinChangedHandler)(bool);

class IO {
  public:    
    static void init();

    static void setGate(bool);

    static void setTrigger(bool);

    // When set to true, multiplexers are set to output
    // pitch/velocity/gate/trigger from the chain input
    // instead of from the local sequencer
    static void setUseChainedRouting(bool);

    static void setRunningIndicator(bool);

    // Drive multiplexers and decoder for selecting the current step
    static void setStep(uint8_t);

    // write to DAC (SPI)
    static void setPitch(uint16_t);

    // Read from the ADC, processing the result with a handler function
    static void readAdc(AdcReadHandler);

    // Routinely read port expander values
    static void readPortExp();

    // Read the cached data from port expander
    static uint16_t readPortExpCache();

    static bool getPortExpPin(uint8_t);

    static uint8_t getSelectedParam();

    // Read and derive the pressed step from the ADC
    // The step buttons are set up as a little keyboard, resistors between them
    // We read an ADC value to figure out which one's pressed, if any
    static void readSelectedStep();

    static uint8_t getSelectedStep();

    // Note: very limiting but should cover needs pretty well for now
    // Write 4 characters to the display
    static void writeDisplay(String);

    // Writes one of a configuration of LEDs
    // This is an enum which covers needs for now (light one out of a set of 3)
    // but could be updated to take a uint16_t instead to cover LED_INDICATOR_*
    // constant formats directly
    static void writeLeds(LEDs);

    static void setChainOut(bool);
    static bool getChainOut();

    static void setSlideEnabled(bool);

    // Assign button press handlers
    static void onSequenceModeButtonPressed(ButtonPressedHandler);
    static void onGateButtonPressed(ButtonPressedHandler);
    static void onRepeatButtonPressed(ButtonPressedHandler);
    static void onRunModeButtonPressed(ButtonPressedHandler);
    static void onScaleButtonPressed(ButtonPressedHandler);
    static void onResetButtonPressed(ButtonPressedHandler);
    static void onLoadButtonPressed(ButtonPressedHandler);
    static void onSaveButtonPressed(ButtonPressedHandler);
    static void onSlideButtonPressed(ButtonPressedHandler);
    static void onMinNoteArrowButtonPressed(ArrowButtonPressedHandler);
    static void onMaxNoteArrowButtonPressed(ArrowButtonPressedHandler);
    static void onTimeDivisionArrowButtonPressed(ArrowButtonPressedHandler);
    static void onChainInputChanged(PinChangedHandler);

    // External clock tick handler
    static void onExternalClockTick(TickHandler);

  private:
    static void _queueTask(Tasks);
    static void _processQueuedTask();
    static void _taskFinished();
    static void _taskQueueInsertAt(Tasks, uint8_t);
    static bool _taskQueueContainsTask(Tasks);
    static void _executeTask(Tasks);
    static void _taskReadAdc();
    static void _taskReadSelectedStep();
    static void _taskWriteDac();
    static void _taskReadPortExp();
    static void _taskProcessPortExpInterrupt();
    static void _taskWriteDisplay();
    static void _taskWriteLeds();

    static void _processPortExpanderInterrupt();
    static void _processRunStopPressedInterrupt();
    static void _processExternalClockTick();
    static bool _debounceButton(uint8_t);

    static void _internalHandleSequenceModeButtonPressed();
    static void _internalHandleGateButtonPressed();
    static void _internalHandleRepeatButtonPressed();
    static void _internalHandleRunModeButtonPressed();
    static void _internalHandleScaleButtonPressed();
    static void _internalHandleResetButtonPressed();
    static void _internalHandleLoadButtonPressed();
    static void _internalHandleSaveButtonPressed();
    static void _internalHandleSlideButtonPressed();
    

    static void _setupArrowButtonHandler();
    static void _internalHandleUpArrowButtonPressed();
    static void _internalHandleDownArrowButtonPressed();
    static void _handleArrowButtonPressed(bool);

    static void _internalHandleChainInputChanged();

    static void _noopArrowButtonPressedHandler(bool);

    volatile static bool _spiBusy;
    volatile static Tasks _taskQueue[MAX_TASK_QUEUE_LENGTH];
    volatile static uint8_t _taskQueueLength;
    volatile static unsigned int _queuedDacValue;
    volatile static uint8_t _cachedSelectedStep;
    static const unsigned int _stepSize = (ADC_MAX - 8) / (NUM_STEPS + 1);
    static const unsigned int _halfStepSize = _stepSize / 2;
    static String _queuedDisplayValue;
    static uint16_t _queuedLedsValue;
    static AdcReadHandler _adcReadHandler;
    static bool _arrowButtonHandlerSetup;
    volatile static bool _chainOutputCache;
    volatile static uint32_t _debounceLastPressed[PORTEXP_NUM_PINS];

    static ButtonPressedHandler _sequenceModeButtonPressedHandler;
    static ButtonPressedHandler _gateButtonPressedHandler;
    static ButtonPressedHandler _repeatButtonPressedHandler;
    static ButtonPressedHandler _runModeButtonPressedHandler;
    static ButtonPressedHandler _scaleButtonPressedHandler;
    static ButtonPressedHandler _resetButtonPressedHandler;
    static ButtonPressedHandler _loadButtonPressedHandler;
    static ButtonPressedHandler _saveButtonPressedHandler;
    static ButtonPressedHandler _slideButtonPressedHandler;

    static ArrowButtonPressedHandler _minNoteArrowButtonPressedHandler;
    static ArrowButtonPressedHandler _maxNoteArrowButtonPressedHandler;
    static ArrowButtonPressedHandler _timeDivisionArrowButtonPressedHandler;

    static PinChangedHandler _chainInputChangedHandler;
    
    static TickHandler _externalClockTickHandler;

    static MAX72S21 _display;
    static MCP23S17 _portExp;
    static MCP3202 _adc;
    static MCP492X _dac;
};

#endif // MODULE_IO_H
